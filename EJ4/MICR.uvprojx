# Keil uVision project MICR.uvprojx, settings and files
target Cortex-M0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC11A13FHI33/201 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x1800) IROM(0x00000000,0x6000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Cortex_M0
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x6000
  memory RVCT9: RAM 0x10000000 size 0x1800
  group ASM Sources
    ./: asm.s
